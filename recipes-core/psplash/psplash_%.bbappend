SPLASH_IMAGES = "file://wizeline.png;outsuffix=default"
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
